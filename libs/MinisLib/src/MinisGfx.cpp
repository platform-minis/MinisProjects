/**
 * MinisGfx.cpp — software primitive implementations + built-in 8x8 font.
 *
 * These are the backend-agnostic defaults built on top of drawPixel(). The
 * framebuffer backend uses them as-is; vendor wrappers (Adafruit/GxEPD2/Lovyan/
 * Qt) override the hot primitives with native, accelerated equivalents.
 */

#include "MinisGfx.h"

// Off-target weak no-op so a sketch links without a real panel. The WASM mock
// (or a real-hardware sketch) provides a strong definition that actually blits.
#ifndef __EMSCRIPTEN__
extern "C" __attribute__((weak)) void minis_canvas_present(const uint32_t*, int, int) {}
#endif

// ── Filled / outlined primitives ────────────────────────────────────────────

void MinisGfx::fillScreen(const MGColor& c) {
  fillRect(0, 0, width(), height(), c);
}

void MinisGfx::drawFastHLine(int x, int y, int w, const MGColor& c) {
  if (w < 0) { x += w; w = -w; }
  for (int i = 0; i < w; i++) drawPixel(x + i, y, c);
}

void MinisGfx::drawFastVLine(int x, int y, int h, const MGColor& c) {
  if (h < 0) { y += h; h = -h; }
  for (int i = 0; i < h; i++) drawPixel(x, y + i, c);
}

void MinisGfx::drawLine(int x0, int y0, int x1, int y1, const MGColor& c) {
  if (y0 == y1) { drawFastHLine(x0 < x1 ? x0 : x1, y0, abs(x1 - x0) + 1, c); return; }
  if (x0 == x1) { drawFastVLine(x0, y0 < y1 ? y0 : y1, abs(y1 - y0) + 1, c); return; }
  int dx = abs(x1 - x0), sx = x0 < x1 ? 1 : -1;
  int dy = -abs(y1 - y0), sy = y0 < y1 ? 1 : -1;
  int err = dx + dy;
  for (;;) {
    drawPixel(x0, y0, c);
    if (x0 == x1 && y0 == y1) break;
    int e2 = 2 * err;
    if (e2 >= dy) { err += dy; x0 += sx; }
    if (e2 <= dx) { err += dx; y0 += sy; }
  }
}

void MinisGfx::drawRect(int x, int y, int w, int h, const MGColor& c) {
  if (w <= 0 || h <= 0) return;
  drawFastHLine(x, y, w, c);
  drawFastHLine(x, y + h - 1, w, c);
  drawFastVLine(x, y, h, c);
  drawFastVLine(x + w - 1, y, h, c);
}

void MinisGfx::fillRect(int x, int y, int w, int h, const MGColor& c) {
  if (w < 0) { x += w; w = -w; }
  if (h < 0) { y += h; h = -h; }
  for (int j = 0; j < h; j++) drawFastHLine(x, y + j, w, c);
}

// Adafruit-style quarter-circle helper. corners is a 4-bit mask (1=TR,2=TL,4=BL,8=BR).
static void circleHelper(MinisGfx* g, int x0, int y0, int r, uint8_t corners, const MGColor& c) {
  int f = 1 - r, ddF_x = 1, ddF_y = -2 * r, x = 0, y = r;
  while (x < y) {
    if (f >= 0) { y--; ddF_y += 2; f += ddF_y; }
    x++; ddF_x += 2; f += ddF_x;
    if (corners & 0x4) { g->drawPixel(x0 + x, y0 + y, c); g->drawPixel(x0 + y, y0 + x, c); }
    if (corners & 0x2) { g->drawPixel(x0 + x, y0 - y, c); g->drawPixel(x0 + y, y0 - x, c); }
    if (corners & 0x8) { g->drawPixel(x0 - y, y0 + x, c); g->drawPixel(x0 - x, y0 + y, c); }
    if (corners & 0x1) { g->drawPixel(x0 - y, y0 - x, c); g->drawPixel(x0 - x, y0 - y, c); }
  }
}

// Filled quarter-circle helper (delta lets fillRoundRect extend the straight edge).
static void fillCircleHelper(MinisGfx* g, int x0, int y0, int r, uint8_t corners, int delta, const MGColor& c) {
  int f = 1 - r, ddF_x = 1, ddF_y = -2 * r, x = 0, y = r, px = x, py = y;
  delta++;
  while (x < y) {
    if (f >= 0) { y--; ddF_y += 2; f += ddF_y; }
    x++; ddF_x += 2; f += ddF_x;
    if (x < (y + 1)) {
      if (corners & 0x1) g->drawFastVLine(x0 + x, y0 - y, 2 * y + delta, c);
      if (corners & 0x2) g->drawFastVLine(x0 - x, y0 - y, 2 * y + delta, c);
    }
    if (y != py) {
      if (corners & 0x1) g->drawFastVLine(x0 + py, y0 - px, 2 * px + delta, c);
      if (corners & 0x2) g->drawFastVLine(x0 - py, y0 - px, 2 * px + delta, c);
      py = y;
    }
    px = x;
  }
}

void MinisGfx::drawCircle(int cx, int cy, int r, const MGColor& c) {
  if (r < 0) return;
  drawPixel(cx, cy + r, c); drawPixel(cx, cy - r, c);
  drawPixel(cx + r, cy, c); drawPixel(cx - r, cy, c);
  circleHelper(this, cx, cy, r, 0xF, c);
}

void MinisGfx::fillCircle(int cx, int cy, int r, const MGColor& c) {
  if (r < 0) return;
  drawFastVLine(cx, cy - r, 2 * r + 1, c);
  fillCircleHelper(this, cx, cy, r, 0x3, 0, c);
}

void MinisGfx::drawRoundRect(int x, int y, int w, int h, int r, const MGColor& c) {
  if (w <= 0 || h <= 0) return;
  int maxr = ((w < h) ? w : h) / 2;
  if (r > maxr) r = maxr;
  drawFastHLine(x + r, y, w - 2 * r, c);
  drawFastHLine(x + r, y + h - 1, w - 2 * r, c);
  drawFastVLine(x, y + r, h - 2 * r, c);
  drawFastVLine(x + w - 1, y + r, h - 2 * r, c);
  circleHelper(this, x + r, y + r, r, 0x1, c);
  circleHelper(this, x + w - r - 1, y + r, r, 0x2, c);
  circleHelper(this, x + w - r - 1, y + h - r - 1, r, 0x4, c);
  circleHelper(this, x + r, y + h - r - 1, r, 0x8, c);
}

void MinisGfx::fillRoundRect(int x, int y, int w, int h, int r, const MGColor& c) {
  if (w <= 0 || h <= 0) return;
  int maxr = ((w < h) ? w : h) / 2;
  if (r > maxr) r = maxr;
  fillRect(x + r, y, w - 2 * r, h, c);
  fillCircleHelper(this, x + w - r - 1, y + r, r, 0x1, h - 2 * r - 1, c);
  fillCircleHelper(this, x + r, y + r, r, 0x2, h - 2 * r - 1, c);
}

void MinisGfx::drawTriangle(int x0, int y0, int x1, int y1, int x2, int y2, const MGColor& c) {
  drawLine(x0, y0, x1, y1, c);
  drawLine(x1, y1, x2, y2, c);
  drawLine(x2, y2, x0, y0, c);
}

void MinisGfx::fillTriangle(int x0, int y0, int x1, int y1, int x2, int y2, const MGColor& c) {
  // Sort vertices by ascending y (y0 <= y1 <= y2).
  auto swap = [](int& a, int& b) { int t = a; a = b; b = t; };
  if (y0 > y1) { swap(y0, y1); swap(x0, x1); }
  if (y1 > y2) { swap(y2, y1); swap(x2, x1); }
  if (y0 > y1) { swap(y0, y1); swap(x0, x1); }

  if (y0 == y2) {   // degenerate — single horizontal span
    int a = x0, b = x0;
    if (x1 < a) a = x1; else if (x1 > b) b = x1;
    if (x2 < a) a = x2; else if (x2 > b) b = x2;
    drawFastHLine(a, y0, b - a + 1, c);
    return;
  }

  int dx01 = x1 - x0, dy01 = y1 - y0;
  int dx02 = x2 - x0, dy02 = y2 - y0;
  int dx12 = x2 - x1, dy12 = y2 - y1;
  long sa = 0, sb = 0;

  int last = (y1 == y2) ? y1 : y1 - 1;   // include the flat-bottom row when y1==y2
  int y;
  for (y = y0; y <= last; y++) {
    int a = x0 + (int)(sa / dy01);
    int b = x0 + (int)(sb / dy02);
    sa += dx01; sb += dx02;
    if (a > b) swap(a, b);
    drawFastHLine(a, y, b - a + 1, c);
  }
  sa = (long)dx12 * (y - y1);
  sb = (long)dx02 * (y - y0);
  for (; y <= y2; y++) {
    int a = x1 + (int)(sa / dy12);
    int b = x0 + (int)(sb / dy02);
    sa += dx12; sb += dx02;
    if (a > b) swap(a, b);
    drawFastHLine(a, y, b - a + 1, c);
  }
}

// ── Bitmaps ─────────────────────────────────────────────────────────────────

void MinisGfx::drawBitmap(int x, int y, const uint8_t* bitmap, int w, int h, const MGColor& fg) {
  int bytesPerRow = (w + 7) / 8;
  for (int j = 0; j < h; j++)
    for (int i = 0; i < w; i++)
      if (bitmap[j * bytesPerRow + (i >> 3)] & (0x80 >> (i & 7)))
        drawPixel(x + i, y + j, fg);
}

void MinisGfx::drawBitmap(int x, int y, const uint8_t* bitmap, int w, int h, const MGColor& fg, const MGColor& bg) {
  int bytesPerRow = (w + 7) / 8;
  for (int j = 0; j < h; j++)
    for (int i = 0; i < w; i++) {
      bool on = bitmap[j * bytesPerRow + (i >> 3)] & (0x80 >> (i & 7));
      drawPixel(x + i, y + j, on ? fg : bg);
    }
}

void MinisGfx::drawRGBBitmap(int x, int y, const uint16_t* pixels, int w, int h) {
  for (int j = 0; j < h; j++)
    for (int i = 0; i < w; i++)
      drawPixel(x + i, y + j, MGColor::fromRgb565(pixels[j * w + i]));
}

// ── Text (built-in 8x8 software font) ───────────────────────────────────────

void MinisGfx::drawChar(int x, int y, char ch, const MGColor& fg, int size) {
  unsigned char uc = (unsigned char)ch;
  if (uc < 0x20 || uc > 0x7F) return;
  const uint8_t* glyph = MINIS_FONT8X8[uc - 0x20];
  for (int row = 0; row < 8; row++) {
    uint8_t bits = glyph[row];
    for (int col = 0; col < 8; col++) {
      bool on = bits & (1 << col);   // bit 0 = leftmost column
      if (on) {
        if (size == 1) drawPixel(x + col, y + row, fg);
        else fillRect(x + col * size, y + row * size, size, size, fg);
      } else if (_hasTextBg) {
        if (size == 1) drawPixel(x + col, y + row, _bg);
        else fillRect(x + col * size, y + row * size, size, size, _bg);
      }
    }
  }
}

void MinisGfx::drawText(int x, int y, const char* s, const MGColor& fg, int size) {
  if (!s) return;
  if (size < 1) size = 1;
  int cx = x;
  for (const char* p = s; *p; p++) {
    if (*p == '\n') { cx = x; y += 8 * size; continue; }
    drawChar(cx, y, *p, fg, size);
    cx += 8 * size;
  }
}

void MinisGfx::write(char ch) {
  if (ch == '\n') { _cx = 0; _cy += 8 * _textSize; return; }
  if (ch == '\r') { _cx = 0; return; }
  if (_wrap && _cx + 8 * _textSize > width()) { _cx = 0; _cy += 8 * _textSize; }
  drawChar(_cx, _cy, ch, _fg, _textSize);
  _cx += 8 * _textSize;
}

// ── 8x8 bitmap font (printable ASCII 0x20..0x7F) ──────────────────────────────
// Public-domain font8x8_basic (dhepper). bit 0 = leftmost column of each row.
const uint8_t MINIS_FONT8X8[96][8] = {
  {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // 0x20 ' '
  {0x18,0x3C,0x3C,0x18,0x18,0x00,0x18,0x00}, // !
  {0x36,0x36,0x00,0x00,0x00,0x00,0x00,0x00}, // "
  {0x36,0x36,0x7F,0x36,0x7F,0x36,0x36,0x00}, // #
  {0x0C,0x3E,0x03,0x1E,0x30,0x1F,0x0C,0x00}, // $
  {0x00,0x63,0x33,0x18,0x0C,0x66,0x63,0x00}, // %
  {0x1C,0x36,0x1C,0x6E,0x3B,0x33,0x6E,0x00}, // &
  {0x06,0x06,0x03,0x00,0x00,0x00,0x00,0x00}, // '
  {0x18,0x0C,0x06,0x06,0x06,0x0C,0x18,0x00}, // (
  {0x06,0x0C,0x18,0x18,0x18,0x0C,0x06,0x00}, // )
  {0x00,0x66,0x3C,0xFF,0x3C,0x66,0x00,0x00}, // *
  {0x00,0x0C,0x0C,0x3F,0x0C,0x0C,0x00,0x00}, // +
  {0x00,0x00,0x00,0x00,0x00,0x0C,0x0C,0x06}, // ,
  {0x00,0x00,0x00,0x3F,0x00,0x00,0x00,0x00}, // -
  {0x00,0x00,0x00,0x00,0x00,0x0C,0x0C,0x00}, // .
  {0x60,0x30,0x18,0x0C,0x06,0x03,0x01,0x00}, // /
  {0x3E,0x63,0x73,0x7B,0x6F,0x67,0x3E,0x00}, // 0
  {0x0C,0x0E,0x0C,0x0C,0x0C,0x0C,0x3F,0x00}, // 1
  {0x1E,0x33,0x30,0x1C,0x06,0x33,0x3F,0x00}, // 2
  {0x1E,0x33,0x30,0x1C,0x30,0x33,0x1E,0x00}, // 3
  {0x38,0x3C,0x36,0x33,0x7F,0x30,0x78,0x00}, // 4
  {0x3F,0x03,0x1F,0x30,0x30,0x33,0x1E,0x00}, // 5
  {0x1C,0x06,0x03,0x1F,0x33,0x33,0x1E,0x00}, // 6
  {0x3F,0x33,0x30,0x18,0x0C,0x0C,0x0C,0x00}, // 7
  {0x1E,0x33,0x33,0x1E,0x33,0x33,0x1E,0x00}, // 8
  {0x1E,0x33,0x33,0x3E,0x30,0x18,0x0E,0x00}, // 9
  {0x00,0x0C,0x0C,0x00,0x00,0x0C,0x0C,0x00}, // :
  {0x00,0x0C,0x0C,0x00,0x00,0x0C,0x0C,0x06}, // ;
  {0x18,0x0C,0x06,0x03,0x06,0x0C,0x18,0x00}, // <
  {0x00,0x00,0x3F,0x00,0x00,0x3F,0x00,0x00}, // =
  {0x06,0x0C,0x18,0x30,0x18,0x0C,0x06,0x00}, // >
  {0x1E,0x33,0x30,0x18,0x0C,0x00,0x0C,0x00}, // ?
  {0x3E,0x63,0x7B,0x7B,0x7B,0x03,0x1E,0x00}, // @
  {0x0C,0x1E,0x33,0x33,0x3F,0x33,0x33,0x00}, // A
  {0x3F,0x66,0x66,0x3E,0x66,0x66,0x3F,0x00}, // B
  {0x3C,0x66,0x03,0x03,0x03,0x66,0x3C,0x00}, // C
  {0x1F,0x36,0x66,0x66,0x66,0x36,0x1F,0x00}, // D
  {0x7F,0x46,0x16,0x1E,0x16,0x46,0x7F,0x00}, // E
  {0x7F,0x46,0x16,0x1E,0x16,0x06,0x0F,0x00}, // F
  {0x3C,0x66,0x03,0x03,0x73,0x66,0x7C,0x00}, // G
  {0x33,0x33,0x33,0x3F,0x33,0x33,0x33,0x00}, // H
  {0x1E,0x0C,0x0C,0x0C,0x0C,0x0C,0x1E,0x00}, // I
  {0x78,0x30,0x30,0x30,0x33,0x33,0x1E,0x00}, // J
  {0x67,0x66,0x36,0x1E,0x36,0x66,0x67,0x00}, // K
  {0x0F,0x06,0x06,0x06,0x46,0x66,0x7F,0x00}, // L
  {0x63,0x77,0x7F,0x7F,0x6B,0x63,0x63,0x00}, // M
  {0x63,0x67,0x6F,0x7B,0x73,0x63,0x63,0x00}, // N
  {0x1C,0x36,0x63,0x63,0x63,0x36,0x1C,0x00}, // O
  {0x3F,0x66,0x66,0x3E,0x06,0x06,0x0F,0x00}, // P
  {0x1E,0x33,0x33,0x33,0x3B,0x1E,0x38,0x00}, // Q
  {0x3F,0x66,0x66,0x3E,0x36,0x66,0x67,0x00}, // R
  {0x1E,0x33,0x07,0x0E,0x38,0x33,0x1E,0x00}, // S
  {0x3F,0x2D,0x0C,0x0C,0x0C,0x0C,0x1E,0x00}, // T
  {0x33,0x33,0x33,0x33,0x33,0x33,0x3F,0x00}, // U
  {0x33,0x33,0x33,0x33,0x33,0x1E,0x0C,0x00}, // V
  {0x63,0x63,0x63,0x6B,0x7F,0x77,0x63,0x00}, // W
  {0x63,0x63,0x36,0x1C,0x1C,0x36,0x63,0x00}, // X
  {0x33,0x33,0x33,0x1E,0x0C,0x0C,0x1E,0x00}, // Y
  {0x7F,0x63,0x31,0x18,0x4C,0x66,0x7F,0x00}, // Z
  {0x1E,0x06,0x06,0x06,0x06,0x06,0x1E,0x00}, // [
  {0x03,0x06,0x0C,0x18,0x30,0x60,0x40,0x00}, // backslash
  {0x1E,0x18,0x18,0x18,0x18,0x18,0x1E,0x00}, // ]
  {0x08,0x1C,0x36,0x63,0x00,0x00,0x00,0x00}, // ^
  {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0xFF}, // _
  {0x0C,0x0C,0x18,0x00,0x00,0x00,0x00,0x00}, // `
  {0x00,0x00,0x1E,0x30,0x3E,0x33,0x6E,0x00}, // a
  {0x07,0x06,0x06,0x3E,0x66,0x66,0x3B,0x00}, // b
  {0x00,0x00,0x1E,0x33,0x03,0x33,0x1E,0x00}, // c
  {0x38,0x30,0x30,0x3E,0x33,0x33,0x6E,0x00}, // d
  {0x00,0x00,0x1E,0x33,0x3F,0x03,0x1E,0x00}, // e
  {0x1C,0x36,0x06,0x0F,0x06,0x06,0x0F,0x00}, // f
  {0x00,0x00,0x6E,0x33,0x33,0x3E,0x30,0x1F}, // g
  {0x07,0x06,0x36,0x6E,0x66,0x66,0x67,0x00}, // h
  {0x0C,0x00,0x0E,0x0C,0x0C,0x0C,0x1E,0x00}, // i
  {0x30,0x00,0x30,0x30,0x30,0x33,0x33,0x1E}, // j
  {0x07,0x06,0x66,0x36,0x1E,0x36,0x67,0x00}, // k
  {0x0E,0x0C,0x0C,0x0C,0x0C,0x0C,0x1E,0x00}, // l
  {0x00,0x00,0x33,0x7F,0x7F,0x6B,0x63,0x00}, // m
  {0x00,0x00,0x1F,0x33,0x33,0x33,0x33,0x00}, // n
  {0x00,0x00,0x1E,0x33,0x33,0x33,0x1E,0x00}, // o
  {0x00,0x00,0x3B,0x66,0x66,0x3E,0x06,0x0F}, // p
  {0x00,0x00,0x6E,0x33,0x33,0x3E,0x30,0x78}, // q
  {0x00,0x00,0x3B,0x6E,0x66,0x06,0x0F,0x00}, // r
  {0x00,0x00,0x3E,0x03,0x1E,0x30,0x1F,0x00}, // s
  {0x08,0x0C,0x3E,0x0C,0x0C,0x2C,0x18,0x00}, // t
  {0x00,0x00,0x33,0x33,0x33,0x33,0x6E,0x00}, // u
  {0x00,0x00,0x33,0x33,0x33,0x1E,0x0C,0x00}, // v
  {0x00,0x00,0x63,0x6B,0x7F,0x7F,0x36,0x00}, // w
  {0x00,0x00,0x63,0x36,0x1C,0x36,0x63,0x00}, // x
  {0x00,0x00,0x33,0x33,0x33,0x3E,0x30,0x1F}, // y
  {0x00,0x00,0x3F,0x19,0x0C,0x26,0x3F,0x00}, // z
  {0x38,0x0C,0x0C,0x07,0x0C,0x0C,0x38,0x00}, // {
  {0x18,0x18,0x18,0x00,0x18,0x18,0x18,0x00}, // |
  {0x07,0x0C,0x0C,0x38,0x0C,0x0C,0x07,0x00}, // }
  {0x6E,0x3B,0x00,0x00,0x00,0x00,0x00,0x00}, // ~
  {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, // 0x7F
};
